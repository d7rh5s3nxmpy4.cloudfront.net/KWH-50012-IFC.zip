Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-10-05T04:50:14
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (16)
Name | FlowDirection
8 x  | SOURCE
8 x  | SINK

# IfcFlowTerminal: KWH 8 Floodights,projectors and column projectors
In: Default Building
Type - Description: - Lamp LED - Colour RGBW30, RGBW40 - Die-cast aluminium end-caps - Extruded aluminium housing - Pre-treated before powder coating ensuring high corrosion resistance - Thermal heat dissipation body - Single or double head configuration for all three sizes - Each of the heads can be aimed, adjusted and locked for precise aiming - Single cable entry, through wiring upon request - One IP68 connector supplied with 0.2 m of 3x1.0 sqmm outdoor cable for KWH-50001, KWH-50011, KWH-50021, KWH-50031,KWH-50041, KWH-50051 - Three IP68 connectors supplied with 0.2 m of 3x1.0 sqmm outdoor cable and 2x0.2 m of 2x0.5 sqmm outdoor shielded cable for KWH-50002, KWH-50003, KWH-50012, KWH-50013, KWH-50022, KWH-50023, KWH-50032,KWH-50033, KWH-50042, KWH-50043,KWH-50052, KWH-50053 - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - Clear toughened glass - High-efficiency PMMA lens - Integral control gear - Hot-dipped galvanised steel mounting bracket allows for ceiling, wall or surface mounting; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: KWH, Floodlights,projectors; Housing color: Not specified
General Information - Article number: KWH-50012-VW-N-40; Article name: KWH 8 Floodights,projectors and column projectors; Weight: 13.2 kg; Case length: 26.2 cm; Case width: 44.6 cm; Case height: 30 cm; Uld creation date: 10.05.2022 00:00:00
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 97.6 W
Pset_LightFixtureTypeCommon - NumberOfSources: 8; TotalWattage: 12.3 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN

# IfcFlowTerminal: KWH-50012-N-8040
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-N-8040; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 1069 lm; LightEmitterNominalPower: 12 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: KWH-50012-N-B
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-N-B; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 133 lm; LightEmitterNominalPower: 13 W; Spectrum: 380: 15, 385: 12, 390: 1, 395: 9, 400: 9, 405: 8, 410: 28, 415: 769, 420: 3775, 425: 1037, 430: 26623, 435: 56111, 440: 118825, 445: 22184, 450: 388447, 455: 674983, 460: 987042, 465: 1052478, 470: 896258, 475: 71852, 480: 5464, 485: 372007, 490: 254137, 495: 171549, 500: 113108, 505: 74894, 510: 49984, 515: 34254, 520: 22855, 525: 15103, 530: 10572, 535: 7431, 540: 4725, 545: 3443, 550: 2247, 555: 1246, 560: 1384, 565: 625, 570: 233, 575: 309, 580: 154, 585: 0, 590: 13, 595: 369, 600: 24, 605: 1, 610: 9, 615: 8, 620: 1, 625: 11, 630: 0, 635: 14, 640: 0, 645: 0, 650: 0, 655: 26, 660: 4, 665: 255, 670: 25, 675: 11, 680: 11, 685: 11, 690: 11, 695: 12, 700: 7, 705: 302, 710: 432, 715: 49, 720: 13, 725: 14, 730: 15, 735: 25, 740: 556, 745: 0, 750: 234, 755: 0, 760: 22, 765: 23, 770: 27, 775: 28, 780: 31

# IfcFlowTerminal: KWH-50012-N-G
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-N-G; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 1085 lm; LightEmitterNominalPower: 12 W; Spectrum: 380: 1942, 385: 0, 390: 2385, 395: 0, 400: 117, 405: 669, 410: 51, 415: 0, 420: 946, 425: 196, 430: 0, 435: 1161, 440: 303, 445: 3161, 450: 2805, 455: 5179, 460: 5681, 465: 9363, 470: 16603, 475: 35501, 480: 69058, 485: 126841, 490: 208672, 495: 335484, 500: 531351, 505: 809043, 510: 1097549, 515: 130022, 520: 138858, 525: 1326776, 530: 1130511, 535: 922711, 540: 721425, 545: 557469, 550: 432042, 555: 330862, 560: 249007, 565: 186634, 570: 137761, 575: 101362, 580: 73883, 585: 54769, 590: 41297, 595: 32927, 600: 22431, 605: 19034, 610: 12097, 615: 879, 620: 895, 625: 7762, 630: 5623, 635: 365, 640: 2034, 645: 1532, 650: 1614, 655: 62, 660: 0, 665: 116, 670: 1848, 675: 279, 680: 1733, 685: 151, 690: 0, 695: 1658, 700: 105, 705: 0, 710: 288, 715: 687, 720: 1082, 725: 145, 730: 23, 735: 44, 740: 991, 745: 19, 750: 31, 755: 33, 760: 36, 765: 2, 770: 2076, 775: 284, 780: 63

# IfcFlowTerminal: KWH-50012-N-R
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-N-R; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 529 lm; LightEmitterNominalPower: 10 W; Spectrum: 380: 2732, 385: 1636, 390: 446, 395: 0, 400: 3259, 405: 43, 410: 67, 415: 8, 420: 784, 425: 6957, 430: 135, 435: 1308, 440: 9081, 445: 0, 450: 9, 455: 1087, 460: 687, 465: 598, 470: 6609, 475: 92, 480: 663, 485: 0, 490: 146, 495: 39, 500: 851, 505: 1252, 510: 112, 515: 5823, 520: 154, 525: 725, 530: 5191, 535: 2225, 540: 3952, 545: 0, 550: 44, 555: 4258, 560: 3464, 565: 3893, 570: 10965, 575: 23605, 580: 46391, 585: 93667, 590: 155921, 595: 276011, 600: 492912, 605: 860002, 610: 1531215, 615: 2556221, 620: 4039036, 625: 6285856, 630: 8094158, 635: 6087111, 640: 2945096, 645: 1238895, 650: 555234, 655: 299846, 660: 194193, 665: 122602, 670: 88499, 675: 75667, 680: 53426, 685: 47708, 690: 33622, 695: 24902, 700: 16338, 705: 543, 710: 14221, 715: 8547, 720: 11231, 725: 3263, 730: 1564, 735: 0, 740: 14794, 745: 1883, 750: 24508, 755: 3014, 760: 15277, 765: 21694, 770: 13646, 775: 165, 780: 223

# IfcFlowTerminal: KWH-50012-VW-8040
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-VW-8040; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 1069 lm; LightEmitterNominalPower: 12 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: KWH-50012-VW-B
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-VW-B; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 104 lm; LightEmitterNominalPower: 13 W; Spectrum: 380: 15, 385: 12, 390: 1, 395: 9, 400: 9, 405: 8, 410: 28, 415: 769, 420: 3775, 425: 1037, 430: 26623, 435: 56111, 440: 118825, 445: 22184, 450: 388447, 455: 674983, 460: 987042, 465: 1052478, 470: 896258, 475: 71852, 480: 5464, 485: 372007, 490: 254137, 495: 171549, 500: 113108, 505: 74894, 510: 49984, 515: 34254, 520: 22855, 525: 15103, 530: 10572, 535: 7431, 540: 4725, 545: 3443, 550: 2247, 555: 1246, 560: 1384, 565: 625, 570: 233, 575: 309, 580: 154, 585: 0, 590: 13, 595: 369, 600: 24, 605: 1, 610: 9, 615: 8, 620: 1, 625: 11, 630: 0, 635: 14, 640: 0, 645: 0, 650: 0, 655: 26, 660: 4, 665: 255, 670: 25, 675: 11, 680: 11, 685: 11, 690: 11, 695: 12, 700: 7, 705: 302, 710: 432, 715: 49, 720: 13, 725: 14, 730: 15, 735: 25, 740: 556, 745: 0, 750: 234, 755: 0, 760: 22, 765: 23, 770: 27, 775: 28, 780: 31

# IfcFlowTerminal: KWH-50012-VW-G
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-VW-G; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 860 lm; LightEmitterNominalPower: 12 W; Spectrum: 380: 1942, 385: 0, 390: 2385, 395: 0, 400: 117, 405: 669, 410: 51, 415: 0, 420: 946, 425: 196, 430: 0, 435: 1161, 440: 303, 445: 3161, 450: 2805, 455: 5179, 460: 5681, 465: 9363, 470: 16603, 475: 35501, 480: 69058, 485: 126841, 490: 208672, 495: 335484, 500: 531351, 505: 809043, 510: 1097549, 515: 130022, 520: 138858, 525: 1326776, 530: 1130511, 535: 922711, 540: 721425, 545: 557469, 550: 432042, 555: 330862, 560: 249007, 565: 186634, 570: 137761, 575: 101362, 580: 73883, 585: 54769, 590: 41297, 595: 32927, 600: 22431, 605: 19034, 610: 12097, 615: 879, 620: 895, 625: 7762, 630: 5623, 635: 365, 640: 2034, 645: 1532, 650: 1614, 655: 62, 660: 0, 665: 116, 670: 1848, 675: 279, 680: 1733, 685: 151, 690: 0, 695: 1658, 700: 105, 705: 0, 710: 288, 715: 687, 720: 1082, 725: 145, 730: 23, 735: 44, 740: 991, 745: 19, 750: 31, 755: 33, 760: 36, 765: 2, 770: 2076, 775: 284, 780: 63

# IfcFlowTerminal: KWH-50012-VW-R
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: KWH-50012-VW-R; Light output ratio: 1; Luminous flux: 1069 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 405 lm; LightEmitterNominalPower: 10 W; Spectrum: 380: 2732, 385: 1636, 390: 446, 395: 0, 400: 3259, 405: 43, 410: 67, 415: 8, 420: 784, 425: 6957, 430: 135, 435: 1308, 440: 9081, 445: 0, 450: 9, 455: 1087, 460: 687, 465: 598, 470: 6609, 475: 92, 480: 663, 485: 0, 490: 146, 495: 39, 500: 851, 505: 1252, 510: 112, 515: 5823, 520: 154, 525: 725, 530: 5191, 535: 2225, 540: 3952, 545: 0, 550: 44, 555: 4258, 560: 3464, 565: 3893, 570: 10965, 575: 23605, 580: 46391, 585: 93667, 590: 155921, 595: 276011, 600: 492912, 605: 860002, 610: 1531215, 615: 2556221, 620: 4039036, 625: 6285856, 630: 8094158, 635: 6087111, 640: 2945096, 645: 1238895, 650: 555234, 655: 299846, 660: 194193, 665: 122602, 670: 88499, 675: 75667, 680: 53426, 685: 47708, 690: 33622, 695: 24902, 700: 16338, 705: 543, 710: 14221, 715: 8547, 720: 11231, 725: 3263, 730: 1564, 735: 0, 740: 14794, 745: 1883, 750: 24508, 755: 3014, 760: 15277, 765: 21694, 770: 13646, 775: 165, 780: 223
